# ????????????? FIXME: why ?
#sharing files across recipes.
SYSROOT_DIRS += "${bindir}"
